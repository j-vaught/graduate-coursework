options:
  parameters:
    generate_options: qt_gui
    id: multipath_receive
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: SDR_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: int(915e6)
  states: {}
- name: num_samples
  id: variable
  parameters:
    value: '512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(50e6)
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: num_samples
    filter_source: '''Auto'''
    frequency: int(carrier_freq)
    gain1: '''manual'''
    manual_gain1: SDR_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.2.5
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: int(carrier_freq)
    fftsize: '4096'
    plotwaterfall: 'False'
    rate: '100'
    showrf: 'True'
    type: complex
    wintype: window.WIN_KAISER
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    size: num_samples
    srate: samp_rate
    type: float
    update_time: '0.05'
    ylabel: Gain [dB]
    ymax: '0'
    ymin: '-50'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0

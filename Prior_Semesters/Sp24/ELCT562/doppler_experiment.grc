options:
  parameters:
    generate_options: qt_gui
    id: doppler_experiment
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: int(5.9e9+100e3)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(500e3)
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: 2**15
    filter_source: '''Auto'''
    frequency: int(5.9e9)
    gain1: '''manual'''
    manual_gain1: '55'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.5
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '32768'
    type: complex
    update_time: '0.0010'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    rate: '1000'
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
